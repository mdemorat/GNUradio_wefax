options:
  parameters:
    generate_options: qt_gui
    id: noaa_fax_demod_final
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: afsk
  id: variable_qtgui_range
  parameters:
    label: AFSK Difference
    start: '0'
    step: '10'
    stop: '600'
    value: '400'
  states: {}
- name: audio_cut
  id: variable
  parameters:
    value: '2700'
  states: {}
- name: deci_0
  id: variable
  parameters:
    value: '4'
  states: {}
- name: deci_1
  id: variable
  parameters:
    value: '8'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Align
    rangeType: int
    start: '0'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: up_conv + main_freq + usb_offset
  states: {}
- name: fw_xlat_0
  id: variable_qtgui_entry
  parameters:
    label: xtling LPF filter width Hz
    type: real
    value: 2.6e3
  states: {}
- name: main_freq
  id: variable_qtgui_chooser
  parameters:
    label: Select Fax Frequency
    label0: 4235kHz
    label1: 6340.5kHz
    label2: 9110kHz
    label3: 12750kHz
    num_opts: '4'
    option0: '4235e3 '
    option1: 6340.5e3
    option2: '9110e3 '
    option3: '12750e3 '
    orient: Qt.QHBoxLayout
    type: real
    value: '9110e3 '
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1536000'
  states: {}
- name: sdr_gain
  id: variable_qtgui_range
  parameters:
    label: SDR gain
    start: '0'
    step: '10'
    stop: '1000'
    value: '300'
  states: {}
- name: up_conv
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: usb_offset
  id: variable
  parameters:
    value: '-1900'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '.001'
    stop: '2'
    value: '.0197'
  states: {}
- name: we_freq
  id: variable_qtgui_entry
  parameters:
    label: 'weaver Freq:'
    type: int
    value: '1300'
  states: {}
- name: xlat_0
  id: variable_qtgui_range
  parameters:
    label: first Xlating Filter
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '-1300'
  states: {}
- name: xlat_1
  id: variable_qtgui_range
  parameters:
    label: xlating 2
    start: '-3000'
    step: '10'
    stop: '3000'
    value: '-1950'
  states: {}
- name: xlat_fw_1
  id: variable_qtgui_range
  parameters:
    label: NOAA decode Xlat filter width
    start: '1'
    step: '100'
    stop: '10000'
    value: '5000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ((samp_rate/deci_0)/deci_1)/(2*math.pi*afsk)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: we_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/deci_0
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: we_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/deci_0
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1000'
    low_cutoff_freq: '1'
    samp_rate: samp_rate/(deci_1 *deci_0)
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay * 4800
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: sdr_gain
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: final_test_4.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: fft_tab
  id: qtgui_tab_widget
  parameters:
    label0: After first xlating
    label1: After weaver
    label2: ASFK align
    label3: waterfall
    num_tabs: '4'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: xlat_0
    decim: deci_0
    nthreads: '3'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate/2,fw_xlat_0,1000)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlat_1
    decim: '1'
    samp_rate: samp_rate/deci_0/deci_1
    taps: firdes.low_pass(1,samp_rate/deci_0/deci_1,xlat_fw_1,200)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_cut
    decim: deci_1
    gain: '1'
    samp_rate: samp_rate/deci_0
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/(deci_1 *deci_0)
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/deci_0
    fc: '0'
    fftsize: '8192'
    gui_hint: fft_tab@0
    name: after first xlating
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: (samp_rate/deci_0)/deci_1
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    gui_hint: fft_tab@1
    name: after weaver
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: (samp_rate/deci_0)/deci_1
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    gui_hint: fft_tab@2
    name: AFSK align
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: '24000'
    nrows: '500'
    samp_rate: samp_rate/deci_1/deci_0
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: fft_tab@3
    name: waterfall
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: '25'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_1, '0', analog_quadrature_demod_cf_0, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_xx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_xx_1, '0']
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_multiply_const_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
